keel input network
keel-star.net
bulb input network
bulb-star.net
wing input network
none
keel output network
klbl-star.net
bulb output network
blkl-star.net
   imo   jmo
    30     9
itertm      omegtm
   200         0.8
itergr      omeggr    wp  plim
   200         0.8   0.1   0.1
    ib    it    il    ir   ibl   ibr   itl   itr   ilb   ilt   irb   irt
     1     1     1     1     0     0     0     0     0     0     0     0
    gb    gt    gl    gr   gbl   gbr   gtl   gtr   glb   glt   grb   grt
  0.20  0.20  0.05  0.05  0.02  0.02  0.02  0.02  0.02  0.02  0.02  0.02
 ibigb ismlb ibigt ismlt ibigl ismll ibigr ismlr
     0     0     0     0     0     0     0     0
 ikleb ikteb
    09    18
