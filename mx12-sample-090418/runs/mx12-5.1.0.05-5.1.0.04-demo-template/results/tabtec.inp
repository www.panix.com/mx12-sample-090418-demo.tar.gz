tabtec.7.1.1.2 input file ... case title
mx12 with wings and tab, transitional / mx12-5.1.0.05-5.1.0.04-demo
     velin    velout      visc      dens    sclmod
       1.0   1.94386  .1218e-2    1025.0       1.0
     ssail     csail     bsail     qsail
       1.0       1.0       1.0       0.0
     sstat     cstat     bstat     qstat
       1.0       1.0       1.0       0.0
     svisc     cvisc     bvisc     qvisc
   67.2000   17.2000   17.2000       1.0
     shdyn     chdyn     bhdyn     qhdyn
   67.2000   17.2000   17.2000       1.0
      sref      cref      bref      qref
       1.0       1.0       1.0       0.0
     istat     ivisc     ileak     irest     isurf
         1        -1         1         1         0
database network directory
none
ivhull    hull network
    3     hull.net
ivkeel    keel network
    6     klbl.net
ivbulb    bulb network
    3     blwg.net
ivwing    wing network
    6     wgbl.net
ivrudr    rudr network
    6     rudr.net
ivfrud    frud network
    0     none
