# title
mx12-5.1.0.05-5.1.0.04-demo
#    isavf
         4
#   xdatum    ydatum    zdatum
    0.0000    0.0000    0.0000
#     sref      cref
      67.2      17.2
#    xfrnt     xback     zside
     -1.50     +1.75     +1.15
#     grav      dens      visc
   9.80665    1025.0 1218.e-06
#   xftab1    yftab1    xftab2    yftab2
     -8.85      0.00     -8.60      2.63
#   xktab1    yktab1    xktab2    yktab2
    0.7000    0.0000    0.7000    4.0000
#   xrtab1    yrtab1    xrtab2    yrtab2
      8.65      0.00      8.90      2.63
#   ispnhl    ispnkl    ispnbl    ispnwg    ispnfr    ispnrd
         0        -1         0        -1         0        -1
#   vcgmwl
    0.0100
#    wcrew   lcgcrew   vcgcrew
   19500.0    0.8125    0.0100
#    wsail   lcgsail   vcgsail
       0.0    0.0000    0.0000
#    wball   lcgball   vcgball
       0.0    0.0000    0.0000
#   ycsail
     -14.5
# database network directory
~/mx12-sample-090418/nets/mx12-demo
# restart directory
~/mx12-sample-090418/runs/mx12-5.1.0.05-5.1.0.04-previous-test
